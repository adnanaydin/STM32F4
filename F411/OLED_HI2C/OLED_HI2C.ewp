# IAR project OLED_HI2C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: hi2c.c hi2c.h io.c io.h main.c oled.c oled.h stm32f4xx_conf.h system.c system.h
  group Core
    ./: delay.s startup_stm32f411xe.s stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group Peripheral
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c
